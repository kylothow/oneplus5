## drivers/oneplus/Kconfig
```kconfig
config OEM_DEBUG_SUPPORT
	bool ""
	default y

config OEM_TRACE_SUPPORT
	bool ""
	depends on OEM_DEBUG_SUPPORT
	default y
```
